EXTRA_OECMAKE:append = " --debug-find-pkg=Qt6Qml" 
EXTRA_OECMAKE:append = " --debug-find-pkg=Qt6QmlTools" 
EXTRA_OECMAKE:append = " --debug-find-pkg=Qt6Graphs"
EXTRA_OECMAKE:append = " -DQT_DEBUG_FIND_PACKAGE=ON"
